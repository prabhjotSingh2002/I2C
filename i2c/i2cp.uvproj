# Keil uVision project i2cp.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: i2cproject +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s i2cdriver.c header.h main.c printingFunc.c setting.c externalinterrupt0.c externalinterrupt1.c externalinterrupt2.c alarmSet.c timer1interrupt.c callSetting.c
    ../uart-interrupt/: uart0interrupt.c
    ../adc-temp/: lcd4bitdriver.c uart0.c
    ../testprac/: timer0driver.c
